# Keil uVision project Project.uvprojx, settings and files
target TCL_GD32F190R8 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: GD32F190R8 GigaDevice
  pack: GigaDevice.GD32F1x0_DFP.3.0.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00002000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: trochili +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F170_190
  c include: ..\..\firmware\GD32F1x0_Firmware_Library_V3.0.0\Firmware;..\..\firmware\GD32F1x0_Firmware_Library_V3.0.0\Firmware\CMSIS;..\..\firmware\GD32F1x0_Firmware_Library_V3.0.0\Firmware\CMSIS\GD\GD32F1x0\Include;..\..\firmware\GD32F1x0_Firmware_Library_V3.0.0\Firmware\GD32F1x0_standard_peripheral\Include;..\..\firmware\GD32F1x0_Firmware_Library_V3.0.0\Firmware\Peripherals\include;..\..\board\Colibri190;..\..\trochili\inc;..\..\trochili\inc\cpu;..\..\trochili\inc\ipc;..\..\trochili\inc\lib;..\..\trochili\inc\mem;..\..\example;C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.5.0\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group ARM_CMSIS
    ../../firmware/GD32F1x0_Firmware_Library_V3.0.0/Firmware/CMSIS/GD/GD32F1x0/Source/: system_gd32f1x0.c
    ../../firmware/GD32F1x0_Firmware_Library_V3.0.0/Firmware/CMSIS/GD/GD32F1x0/Source/ARM/: startup_gd32f1x0.s
  group GD32F10x_FWLib
    ../../firmware/GD32F1x0_Firmware_Library_V3.0.0/Firmware/GD32F1x0_standard_peripheral/Source/: gd32f1x0_adc.c gd32f1x0_can.c gd32f1x0_cec.c gd32f1x0_cmp.c gd32f1x0_crc.c gd32f1x0_dac.c gd32f1x0_dbg.c gd32f1x0_dma.c gd32f1x0_exti.c gd32f1x0_fmc.c gd32f1x0_fwdgt.c gd32f1x0_gpio.c gd32f1x0_i2c.c gd32f1x0_ivref.c gd32f1x0_misc.c gd32f1x0_opa.c gd32f1x0_pmu.c gd32f1x0_rcu.c gd32f1x0_rtc.c gd32f1x0_slcd.c gd32f1x0_spi.c gd32f1x0_syscfg.c gd32f1x0_timer.c gd32f1x0_tsi.c gd32f1x0_usart.c gd32f1x0_wwdgt.c
  group Colibri190_BSP
    ../../board/Colibri190/: colibri_bsp.c colibri_bsp_key.c colibri_bsp_led.c colibri_bsp_uart.c
  group TROCHILI
    ../../trochili/src/: tcl.debug.c tcl.irq.c tcl.timer.c trochili.c tcl.object.c tcl.thread.c tcl.kernel.c
    ../../trochili/src/mem/: tcl.mem.buddy.c tcl.mem.pool.c
    ../../trochili/src/ipc/: tcl.flags.c tcl.ipc.c tcl.mailbox.c tcl.message.c tcl.mutex.c tcl.semaphore.c
    ../../trochili/src/cpu/: tcl.gd32f190.c tcl.gd32f190.keil.asm
  group example_thread
    ../../example/book_chapter_2_thread/: thread_activate_deactivate.c thread_change_priority.c thread_change_slice.c thread_delay_undelay.c thread_init.c thread_suspend_resume.c thread_yield.c
  group example_semaphore
    ../../example/book_chapter_4_semaphore/: semaphore_example1.c semaphore_example2.c semaphore_example3_isr.c semaphore_example4.c semaphore_example5_reset.c semaphore_example6_flush.c semaphore_example7_delete.c semaphore_example8_abort.c semaphore_example9_timeout.c
  group example_mutex
    ../../example/book_chapter_5_mutex/: mutex_example1.c mutex_example2_reset.c mutex_example3_flush.c mutex_example4_delete.c mutex_example5_abort.c
  group example_mailbox
    ../../example/book_chapter_6_mailbox/: mailbox_example1.c mailbox_example2_isr.c mailbox_example3.c mailbox_example4.c mailbox_example5_reset.c mailbox_example6_broadcast.c mailbox_example7_flush.c mailbox_example8_delete.c mailbox_example9_abort.c
  group example_message
    ../../example/book_chapter_7_message/: message_example1.c message_example2_isr.c message_example3.c message_example4.c message_example5_reset.c message_example6_broadcast.c message_example7_flush.c message_example8_delete.c message_example9_abort.c
  group example_flags
    ../../example/book_chapter_8_flags/: flags_example1.c flags_example2_isr.c flags_example3_reset.c flags_example4_flush.c flags_example5_delete.c flags_example6_abort.c
  group example_timer
    ../../example/book_chapter_9_timer/: user_timer_basic_example.c user_timer_config_example.c user_timer_lagticks_example.c
  group example_irq
    ../../example/book_chapter_10_irq/: irq_example1.c irq_example2.c
  group example_memory
    ../../example/book_chapter_11_memory/: memory_buddy_example.c memory_pool_example.c
  group example_board
    ../../example/book_chapter_13_board/: board_example.c
